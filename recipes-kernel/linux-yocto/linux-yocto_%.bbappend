#
# Copyright (C) 2015-2017 Wind River Systems, Inc.
#

require linux-yocto.inc
