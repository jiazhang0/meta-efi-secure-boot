#
# Copyright (C) 2017 Wind River Systems, Inc.
#

require linux-yocto-efi-secure-boot.inc
